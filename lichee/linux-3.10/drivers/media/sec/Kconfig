## lichee/linux-3.10/drivers/media/sec/Kconfig
```kconfig
config SEC
	tristate "sunxi sec support"
	default y
	---help---
	  This is the driver for sunxi sec.
```
